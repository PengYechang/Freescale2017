# Keil uVision project Freescale 2016.uvprojx, settings and files
target MK60DN (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Freescale 2016 +hex
  c flags: Optim=1 wLevel=2
  c define: MK60D10,SingleMotor
  c misc: --c99
  c include: ..\SRC\FWLIB;..\SRC\FWLIB\ADC;..\SRC\FWLIB\COMMON;..\SRC\FWLIB\CPUIDY;..\SRC\FWLIB\DAC;..\SRC\FWLIB\DMA;..\SRC\FWLIB\DSP;..\SRC\FWLIB\FTM;..\SRC\FWLIB\GPIO;..\SRC\FWLIB\I2C;..\SRC\FWLIB\LPTMR;..\SRC\FWLIB\PIT;..\SRC\FWLIB\RTC;..\SRC\FWLIB\SD;..\SRC\FWLIB\SPI;..\SRC\FWLIB\SYSTICK;..\SRC\FWLIB\UART;..\SRC\FWLIB\VREF;..\SRC\FWLIB\WDOG;..\SRC\HARDWARE\CAMERA;..\SRC\HARDWARE\ENCODER;..\SRC\HARDWARE\FREECARS;..\SRC\HARDWARE\LEDBUZ;..\SRC\HARDWARE\KEYBOARD;..\SRC\HARDWARE\OLED;..\SRC\HARDWARE\MOTOR;..\SRC\HARDWARE\SERVO;..\SRC\HARDWARE\BOMASWITCH;..\SRC\HARDWARE\TIMER;..\SRC\HARDWARE\VOLTAGEDETECT;..\SRC\USER;..\SRC\ALGORITHM;..\SRC\ALGORITHM\IMGDEAL;..\SRC\ALGORITHM\PID;..\SRC\STARTUP\DeviceSupport;..\SRC\STARTUP\CoreSupport;..\SRC\HARDWARE\NRF24L01;..\SRC\ALGORITHM\DIRCTRL;..\SRC\ALGORITHM\SPEEDCTRL;..\SRC\ALGORITHM\MYMATH;..\SRC\ALGORITHM\FUZZYSPEED;..\SRC\HARDWARE\STOPCAR;..\SRC\HARDWARE\SD;..\SRC\HARDWARE\STARTLINE;..\SRC\HARDWARE\CCD;..\SRC\HARDWARE\USART;..\SRC\HARDWARE\IMAGEDEAL
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group STARTUP
    ../SRC/STARTUP/DeviceSupport/: startup_MK60D10.s system_MK60D10.c
  group USER
    ../SRC/USER/: main.c isr.c
  group FWLIB
    ../SRC/FWLIB/ADC/: adc.c
    ../SRC/FWLIB/COMMON/: common.c
    ../SRC/FWLIB/CPUIDY/: cpuidy.c
    ../SRC/FWLIB/DAC/: dac.c
    ../SRC/FWLIB/DMA/: dma.c
    ../SRC/FWLIB/FTM/: ftm.c
    ../SRC/FWLIB/GPIO/: gpio.c
    ../SRC/FWLIB/I2C/: i2c.c
    ../SRC/FWLIB/LPTMR/: lptmr.c
    ../SRC/FWLIB/PIT/: pit.c
    ../SRC/FWLIB/RTC/: rtc.c
    ../SRC/FWLIB/SD/: sd.c
    ../SRC/FWLIB/SPI/: spi.c
    ../SRC/FWLIB/SYSTICK/: SysTick.c
    ../SRC/FWLIB/UART/: uart.c
    ../SRC/FWLIB/VREF/: vref.c
    ../SRC/FWLIB/WDOG/: wdog.c
  group HARDWAKE
    ../SRC/HARDWARE/FREECARS/: FreeCars.c
    ../SRC/HARDWARE/CAMERA/: camera.c
    ../SRC/HARDWARE/BOMASWITCH/: BomaSwitch.c
    ../SRC/HARDWARE/SERVO/: servo.c
    ../SRC/HARDWARE/USART/: usart.c
    ../SRC/HARDWARE/IMAGEDEAL/: image_control.c
  group ALGORITHM
    ../SRC/ALGORITHM/MYMATH/: MyMath.c
    ../SRC/ALGORITHM/FUZZYSPEED/: fuzzzySpeed.c
  group DOCUMENT
    ../SRC/DOCUMENT/: Record.txt
